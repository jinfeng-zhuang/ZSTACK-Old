# Keil uVision project zstack.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: zstack (library)
  AfterMake: cmd.exe /C copy .\Objects\zstack.lib ..\Library
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Algo
    ./Algo/: fft.cpp hanning_window.cpp linear_regression.cpp statistics.cpp wavegen.cpp
  group Misc
    ./Misc/: print_usage.cpp count_char.cpp file_append.cpp file_load.cpp file_save.cpp fsize.cpp hexdump.cpp load_png.cpp log.cpp mem_format_parser.cpp param_parser.cpp readlines.cpp replace_char.cpp ringbuf.cpp split.cpp trim.cpp
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6
