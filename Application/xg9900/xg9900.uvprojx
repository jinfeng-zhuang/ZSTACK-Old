# Keil uVision project xg9900.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: xg9900
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: main.cpp usage.cpp version.cpp simulate_data.cpp
    ../../Library/: zstack.lib
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6, Device:Startup 1.0.1
